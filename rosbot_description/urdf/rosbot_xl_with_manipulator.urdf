Commit message: Manipulation documentation

File: rosbot_description/urdf/rosbot_xl_with_manipulator.urdf (robot description, URDF)
Before this commit: robot rosbot_xl, 20 links, 19 joints
Links:
- link end_effector_link: geometry 
